# Keil uVision project RM_frame.uvprojx, settings and files
target RM_frame (6120000::V6.12::.\ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_frame +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx,USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Headers; ..\AdditionalFunctions\Inc; ..\BasicComponents\Inc; ..\Configurations; ..\BSP\Inc; ..\Middleware\Inc; ..\Multimedia\Inc; ..\Multimedia\Lib; ..\UpperTasks\Inc; ..\Hero\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.cpp gpio.c adc.c can.c dac.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group AdditionalFunctions
    ../AdditionalFunctions/Src/: CapTask.cpp CANDevice.cpp
  group BasicComponents
    ../BasicComponents/Src/: CANTask.cpp CarTask.cpp ChassisTask.cpp GimbalTask.cpp IMUTask.cpp JudgeTask.cpp MotorTask.cpp PIDTask.cpp RemoteTask.cpp AutoAimTask.cpp ShootTask.cpp KeyMouseControlTask.cpp LeverControlTask.cpp GateTask.cpp Parameter.cpp
    ../Hero/Src/: ClimbTask.cpp
    ../BasicComponents/Inc/: offical_Judge_Handler.h
  group BSP
    ../BSP/Src/: KeyMonitor.cpp LED.cpp
  group Middleware
    ../Middleware/Src/: SoftTimer.cpp
  group Multimedia
    ../Multimedia/Src/: DanceWithBGM.cpp MusicAutoPlay.cpp
  group UpperTasks
    ../UpperTasks/Src/: CallbackAdministration.cpp
software components: CMSIS:CORE 5.4.0
